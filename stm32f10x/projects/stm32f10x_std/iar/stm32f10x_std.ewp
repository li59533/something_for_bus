# IAR project stm32f10x_std.ewp, settings and files
configuration ZSPLAT (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\Components\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\Components\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Components\BSP\stm32f10x_bsp\conf; ..\..\..\Components\BSP\stm32f10x_bsp\inc; ..\source\application; ..\..\..\Components; ..\..\..\Components\BSP; ..\..\..\Components\MDL\clog; ..\..\..\Components\MDL\osal\src; ..\..\..\Components\MDL\osal\ports; ..\source\application\sample_task; ..\source\application\hal_task; ..\source\application\user_task; ..\source\fml; ..\..\..\Components\MDL\sx127x\sx1276; ..\..\..\Components\MDL\sx127x; ..\source\application\lora_task; ..\..\..\..\Components\STM32_USB-FS-Device_Driver\inc; ..\..\..\Components\MDL\usb_vcp; ..\..\..\..\Components\STM32_USB-FS-Device_Driver\src; ..\..\..\Components\MDL; ..\source\fml\lora; ..\source\fml\key; ..\source\application\wifi_task; ..\source\fml\esp8266; ..\source\fml\w5500; ..\source\application\net_task; ..\..\..\Components\MDL\cdb; ..\source\fml\system; ..\..\..\Components\MDL\wproto; ..\..\..\Components\MDL\w5500\Ethernet; ..\..\..\Components\MDL\w5500\Ethernet\W5500; ..\..\..\Components\MDL\w5500\Internet; ..\..\..\Components\MDL\w5500\Internet\DHCP; ..\source\fml\w5500; ..\..\..\Components\MDL\MQTTPacket\src; ..\source\application\mqtt_task; ..\source\fml\mqtt; ..\..\..\Components\MDL\header; ..\..\..\Components\MDL\MQTTPacket\samples; ..\..\..\Components\BSP\cc1101; ..\source\application\cc1101_task; ..\..\..\Components\MDL\cshell; ..\..\..\components\BSP\stm32f10x_bsp\callback; ..\..\..\components\MDL\rttviewer; ..\source\application\gprs_task; ..\source\application\lcd_task; ..\source\application\modbusmaster_task; ..\source\fml\modbusmaster; ..\source\fml\gprs; ..\source\fml\zsproto; ..\..\..\..\components\Utilities; ..\source\application\maintain_task; ..\source\fml\maintain; ..\source\fml\lcd; ..\source\fml\clock; ..\source\fml\hj212; ..\source\fml\historydata
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ZSCA-1A01-S5_MainBoard_Vx.x.x_Full_V.hex
  ILINK.IlinkOutputFile: simple_main.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FC (ARM, debug)
  as the first configuration, except:
configuration MC20 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  ICCARM.CCIncludePath2: ..\..\..\..\Components\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\Components\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Components\BSP\stm32f10x_bsp\conf; ..\..\..\Components\BSP\stm32f10x_bsp\inc; ..\source\application; ..\..\..\Components; ..\..\..\Components\BSP; ..\..\..\Components\MDL\clog; ..\..\..\Components\MDL\osal\src; ..\..\..\Components\MDL\osal\ports; ..\source\application\sample_task; ..\source\application\hal_task; ..\source\application\user_task; ..\source\fml; ..\..\..\Components\MDL\sx127x\sx1276; ..\..\..\Components\MDL\sx127x; ..\source\application\lora_task; ..\..\..\..\Components\STM32_USB-FS-Device_Driver\inc; ..\..\..\Components\MDL\usb_vcp; ..\..\..\..\Components\STM32_USB-FS-Device_Driver\src; ..\..\..\Components\MDL; ..\source\fml\lora; ..\source\fml\key; ..\source\application\wifi_task; ..\source\fml\esp8266; ..\source\fml\w5500; ..\source\application\net_task; ..\..\..\Components\MDL\cdb; ..\source\fml\system; ..\..\..\Components\MDL\wproto; ..\..\..\Components\MDL\w5500\Ethernet; ..\..\..\Components\MDL\w5500\Ethernet\W5500; ..\..\..\Components\MDL\w5500\Internet; ..\..\..\Components\MDL\w5500\Internet\DHCP; ..\source\fml\w5500; ..\..\..\Components\MDL\MQTTPacket\src; ..\source\application\mqtt_task; ..\source\fml\mqtt; ..\..\..\Components\MDL\header; ..\..\..\Components\MDL\MQTTPacket\samples; ..\..\..\Components\BSP\cc1101; ..\source\application\cc1101_task; ..\..\..\Components\MDL\cshell; ..\..\..\components\BSP\stm32f10x_bsp\callback; ..\..\..\components\MDL\rttviewer; ..\source\application\gprs_task; ..\source\application\lcd_task; ..\source\application\modbusmaster_task; ..\source\fml\modbusmaster; ..\source\fml\gprs; ..\source\fml\zsproto; ..\..\..\..\components\Utilities; ..\source\application\maintain_task; ..\source\fml\maintain; ..\source\fml\lcd; ..\source\fml\clock; ..\source\fml\hj212; ..\source\fml\historydata; ..\source\fml\gprs\port; ..\source\fml\gprs; ..\source\fml; ..\source\application\gprs_task; ..\source\fml\gprs\src; ..\source\fml\mc20\app; ..\source\fml\mc20\port; ..\source\fml\mc20\src; ..\source\application\mc20_task
  OBJCOPY.OOCOutputFile: stm32f10x_std.hex
  group application
    ../source/application/: main.c self_def.h stm32f10x_it.c version.c
  group application/hal_task
    ../source/application/hal_task/: hal_task.c hal_task.h
  group application/mc20_task
    ../source/application/mc20_task/: mc20_task.c
  group application/user_task
    ../source/application/user_task/: user_task.c user_task.h
  group bsp
    ../../../components/BSP/: bsp_init.c
  group bsp/stm32f10x_bsp/src
    ../../../components/BSP/stm32f10x_bsp/src/: stm32f10x_bsp_systick.c
  group cmsis
    ../../../../components/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../../components/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_md.s
    ../../../../components/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group fml
    ../source/fml/: fml_init.c
  group fml/clock
    ../source/fml/clock/: clock.c clock.h
  group fml/mc20/app
    ../source/fml/mc20/app/: mc20_app.c
  group fml/mc20/port
    ../source/fml/mc20/port/: mc20_port.c
  group fml/mc20/src
    ../source/fml/mc20/src/: mc20_ATcmd.c mc20_conf.c mc20_core.c mc20_gprs_conf.c mc20_queue.c
  group fml/system
    ../source/fml/system/: system_info.c system_info.h system_init.c system_init.h system_param.c system_param.h
  group mdl
    ../../../components/MDL/: cqueue.c cqueue.h cstring.c cstring.h
  group mdl/clog
    ../../../components/MDL/clog/: clog.c
    ../../../Components/MDL/clog/: clog.h
  group mdl/clog/flash
    ../../../components/MDL/clog/: flash_log.c flash_log.h
  group mdl/clog/rtt
    ../../../components/MDL/clog/: rtt_log.c rtt_log.h
  group mdl/clog/uart
    ../../../components/MDL/clog/: serial_log.c serial_log.h
  group mdl/cshell
    ../../../components/MDL/cshell/: cshell.c cshell.h cshell_port.c cshell_port.h cshell_user.c cshell_user.h
  group mdl/osal/ports
    ../../../Components/MDL/osal/ports/: osal_cpu.h
  group mdl/osal/src
    ../../../Components/MDL/osal/src/: osal.h osal_cfg.h
    ../../../components/MDL/osal/src/: osal_clock.c osal_core.c osal_msg.c osal_task.c osal_timeout.c osal_timer.c
  group mdl/RTTViewer
    ../../../components/MDL/rttviewer/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group STM32F10x_StdPeriph_Driver
    ../../../../components/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uti
    ../../../../components/Utilities/: aes.c crc.c des.c md5.c tea.c
